# Keil uVision project smartclock.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smartclock +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\FWLIB\inc;..\STARTUP;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c
  group FWLIB
    ../FWLIB/src/: stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_pwr.c stm32f10x_fsmc.c
  group HARDWARE
    ../FWLIB/src/: stm32f10x_bkp.c stm32f10x_rcc.c
    ../HARDWARE/: TM1637.c rtc.c led.c key.c MP3.c usart3.c ESP01.c lcd.c font.h display.c
  group STARTUP
    ../HARDWARE/: usart2.c
    ../STARTUP/: startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: main.c system_stm32f10x.c
